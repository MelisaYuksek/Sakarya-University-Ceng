# Keil uVision project 30-4Farasienbuyukadresleriaktar.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RC2 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF)  XRAM (0-0x3FF) CLOCK(40000000) MODP2
  output: 30-4Farasienbuyukadresleriaktar +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 30-4Farasienbuyukadresleriaktar.asm
